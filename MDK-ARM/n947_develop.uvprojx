# Keil uVision project n947_develop.uvprojx, settings and files
target TZ_Disabled (6230000::V6.23::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.19.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: n947_develop
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\NXP\frdmmcxn947_hello_world_cm33_core0\drivers;.\NXP\frdmmcxn947_hello_world_cm33_core0\utilities;.\NXP\frdmmcxn947_hello_world_cm33_core0\component;.\NXP\frdmmcxn947_hello_world_cm33_core0\board;.\NXP\frdmmcxn947_hello_world_cm33_core0\component\uart;.\NXP\frdmmcxn947_hello_world_cm33_core0\utilities\debug_console_lite;.\NXP\frdmmcxn947_hello_world_cm33_core0\utilities\str;..\Development\USBD\inc
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\n947_develop.sct
  group sys
    ./sys/: main.c startup_MCXN947_cm33_core0.c
  group usbd
    ../Development/USBD/src/: usbd_sys.c
  group board
    ./NXP/frdmmcxn947_hello_world_cm33_core0/board/: board.c clock_config.c hardware_init.c peripherals.c pin_mux.c
  group fsl_lib
    ./NXP/frdmmcxn947_hello_world_cm33_core0/component/uart/: fsl_adapter_lpuart.c
    ./NXP/frdmmcxn947_hello_world_cm33_core0/utilities/debug_console_lite/: fsl_debug_console.c
    ./NXP/frdmmcxn947_hello_world_cm33_core0/utilities/str/: fsl_str.c
    ./NXP/frdmmcxn947_hello_world_cm33_core0/utilities/: fsl_assert.c
    ./NXP/frdmmcxn947_hello_world_cm33_core0/drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_gpio.c fsl_lpflexcomm.c fsl_lpuart.c fsl_reset.c fsl_spc.c
software components: CMSIS:CORE 6.1.0, Device:CMSIS:MCXN947_header 1.0.0, Device:CMSIS:MCXN947_system 1.0.0
